# Keil uVision project empty.uvprojx, settings and files
target empty (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..;..\user;..\..\Driver_Library\source\third_party\CMSIS\Core\Include;..\..\Driver_Library\source;..\eide\.cmsis\include;RTE\_empty_LP_MSPM0G3507_nortos_keil;RTE\_empty;..\bsp\borad;..\app\delay;..\bsp\OLED;..\app\uart;..\bsp\JY61P;..\bsp\gray;..\bsp\zdt_motor;..\app\pid;..\app\menu;..\app\start;..\app\filter;..\bsp\tb6612;..\bsp\encoder
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: mspm0g3507.sct
  link misc: ..\..\Driver_Library\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group api
    ../app/delay/: delay.c
    ../app/uart/: uart.c
  group bsp
    ../bsp/borad/: borad.c
    ../bsp/OLED/: oled.c oled_start.c
    ../bsp/JY61P/: jy61p.c
    ../bsp/gray/: No_Mcu_Ganv_Grayscale_Sensor.c ADC.c
    ../bsp/zdt_motor/: zdt_motor.c
    ../bsp/tb6612/: tb6612.c
    ../bsp/encoder/: encoder.c
  group app
    ../app/pid/: pid.c
    ../app/menu/: menu.c
    ../app/start/: start.c
    ../app/filter/: filter.c
  group user
    ../user/: empty.c empty.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ../gcc/: startup_mspm0g350x_gcc.c
    ./: startup_mspm0g350x_uvision.s
